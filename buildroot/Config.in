## buildroot/package/receiver/Config.in
```kconfig
config BR2_PACKAGE_RECEIVER
	bool "C television, radio and Ethernet receiver"
	depends on BR2_TOOLCHAIN_HAS_THREADS
```
